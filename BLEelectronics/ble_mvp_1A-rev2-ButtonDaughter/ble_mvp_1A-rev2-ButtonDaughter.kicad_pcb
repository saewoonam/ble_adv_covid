# Repository saewoonam/ble_adv_covid

File README.md:

# nRF5 nordic devices project to implement bluetooth part of Google/Apple contact tracing bluetooth protocol, radio part works for BBC microbit, Adafruit nRF52840 feather, nrf52840 dongle, Particle Gen 3 devices (Argon, Boron, Xenon), Sparkfun Pro nRF52840 mini, and our custom open source hardware we are developing
[Apple/Google announcment](https://www.apple.com/covid19/contacttracing/)  
[Bluetooth spec](https://covid19-static.cdn-apple.com/applications/covid19/current/static/contact-tracing/pdf/ContactTracing-BluetoothSpecificationv1.1.pdf)

#  Latest codes works using Zephyr Development environment
##  Nordic Devices, nrf52840 Dongle or nRF52840DK
##  Code in zephyr/bt_cdc_fs
##  This version seems to get bt, usb-serial (CDC), and flash memory working together
##
1.  Works to advertise and scan, encounter BT signals
2.  Logs data to external flash memory when requested via usb serial
3.  Dumps logged data from flash memory to usb serial port when requested
4.  Following commands implemented via usb serial
    * 'r':  Toggles on/off streaming raw scans results to serial port
    * 'g':  Get data from flash memory and send over serial port
    * 'c':  Clear flash memory
    * 'k':  Toggles on/off stream of  raw ecounter packets to the debugger port
    * 'l':  List files on flash memory to debugger
    * 'w':  Start writing encounter packets to the flash memory
    * 's':  Stop writing encounter packets to the flash memory

##  For older code look in zephyr/bt_cdc folder
##  Issues
1.  This works... does not implement anything to flash memory
2.  Stripped out all "helper" code from covid2 code to eliminate memory leak
    between the BT scan and the CDC
3.  Needs to be stress tested...
4.  Also seems to solve the usb disconnect problem...   It recovers when usb is
    disconnected... Also needs to be stress tested.
5.  Does implement the latest protocol

##  Old version in zephyr/covid2 folder
##  Issues
1.  Does not implement latest Apple/Google protocol
2.  BT and CDC are not playing well together.
3.  Device crashes if USB disconnects during serial port transmission

#  BBC:Microbit
##  This works and advertises the accelerometer and compass readings instead of a RPI in the google/apple protocol
## Code
    *  Latest version in ubit/zephyr/all_no_fs
    *  Other versions with bt, accelerometer, compass separately in other folders
    *  Look at README in all_no_fs folder to access data from scanning

#  Adafruit notes

##  Implementation notes:
1.  Data is logged in external Flash memory
2.  Data can be fetched by sending commands via usb-serial to the device
3.  time information can be transferred to the device via usb-serial, untested

##  Things missing for Adafruit
1.  Cryptographic code for calculting RPI
2.  Real time clock for crypto
3.  How to handle error?

##  Remaining minor issues
1. Figure out how to port this to the nRF52840 Dongle from Nordic Semiconductors with their SDK so it can be ported to other types of dongles.
2. The scanner does not seem to continuously receive advertisements... It could be because of the interval settings, but I have not checked carefully.   Need to do that.
3. Check if it can be powered by an external source and still be connected to a computer as needed to retrieve data or sync the clock
4.  Need to sort out the byte order of the UUID.

##  Requirements
1.  Hardware: Adafruit nRF52840
2.  Libraries: nRF52 Adafruit arduino library

##  Modifications to nRF52 library
1.  Need to modify files installed by the arduino IDE to run the board.  The base location by operating system is
* macOS  : `~/Library/Arduino15/packages/adafruit/hardware/nrf52`
* Linux  : `~/.arduino15/packages/adafruit/hardware/nrf52`
* Windows: `%APPDATA%\Local\Arduino15\packages\adafruit\hardware\nrf52`
2. Need to replace these two files  which are located relative to the base path above in 0.19.0/libraries/Bluefruit52Lib/src  
   a. BLEAdvertising.cpp  
   b. BLEAdvertising.h  
3. These files are modified so that the advertising data which contains the rotating proximity identifier can be changed easily.  The modified files are in the subdirectory modified_files in the repo
  
## Tested with Arduino 1.18.12, nRF52 library 0.19

#  nRF52840 dongle with nRF5 SDK
## Requirements
1. nRFConnect on computer to program
2. Uses SoftDevice 7.0
3. Uses nRF5 SDK v16

## Compiler setup
1.  Compiles only with the SEGGER IDE so far, (SaeWoo is using osX).
2.  Look in 'ses' folder in the 'nrf52 dongle/PCA10059' directory
3.   *Must* set up a global macro to the nRF5 SDK... Go to "Tools" from the menu
bar, then go to "Options...->Building -> Build -> Global macros".   Must define
a 'sdk' macro.  For SaeWoo, sdk=/Users/nams/Documents/projects/covid/nrf5/nRF5SDK160098a08e2
4. Now, the project can be built in the git repo, WITHOUT copying to a
   subdirectory of the nrf5 SDK.

## Issues
1. The dongle has no memory to log data, so it sends the data back through usb
   as a serial device
2. Trouble with CDC_ACM interface... Crashes after a while..  Can't figure out
   why.

## Progress so far
1. The app compiles in SEGGER IDE.  I didn't configure any of the other projects.  
2. The app should compile and emit a covid tracing advertisement packet that is consistent with Apple/Google bluetooth spec.
3. Sends contact packets over usb serial back to computer

## LED OUTPUTS
1. Multicolor LED:  Red periodically to indicate advertising (1 per second)
2. Multicolor Blue:  Inidicate detection of contact via bluetooth
3. Multicolor Green:  Serial port write or other serial port related stuff

## Things to do
1.  Implement capability to change advertising packet every 10 to 15 minutes
    (i.e. RPI)
2.  Crytpo
3.  Changing RPI
4.  Write code to log to an add-on flash
5.  Figure out how to power nrf52 via a battery.

#  Particle Argon/Boron

## Requirements
1. Developed using DeviceOS 1.5.0
2. Installed "Particle Workbench"

## Issues
1.  Can't access Flash memory for logging... Need to investigate how
2.  Need to figure out how to push logging data to the web for logging into a
    database for data taking / evaluation
## LED output
1. Blue LED flashes when contact detected

## Things to do for testimg
1. Implement WiFi data logging
2. For remote testing (no wifi), get flash logging working
3. Implement scheme to retrieve data from flash memory

# Sparkfun pro nRF52840 mini
## Requirements
1.  nRF5 Nordic SDK
2.  gnu gcc toolchain, follow sparkfun instructions for setting up

##  Issues
1.  Only implemented advertising

## LED output
1.  Blink when advertising
SaeWoo Nam, started 2020-04-13, last edit 2020-04-19

## KiCad design BLEelectronics/ble_mvp_1A-rev2-ButtonDaughter/ble_mvp_1A-rev2-ButtonDaughter.kicad_pcb

Parts:
J1: Nordic_nRF52840_breakout; Nordic_nRF52840_Narrowed_FeatherHeader; MPN NRF52840-DONGLE
R1, R2: 0; R_0603_1608Metric
S1: Spring_Finger; SpringFingerGeneric; MPN S7131-45R
SW1, SW2: SW_Push; TS-1187A-SMD_button

Connections:
/5Vusb: J1.20 (VBUS)
/BatterySense: J1.17 (P0.31), S1.1
/BigButtonA: J1.16 (P0.29), SW1.1
/BigButtonB: J1.13 (P1.13), SW2.1
/SCL: J1.7 (P1.00)
/SCLK: J1.3 (P0.17)
/SDA: J1.14 (P1.15)
/SI: J1.5 (P0.22)
/SO: J1.2 (P0.15)
/VDD_3V: J1.19 (VDD_nRF)
/~CS~: J1.1 (P0.13)
/~RESET~: J1.6 (P0.24)
/~WP~: J1.4 (P0.20)
GND: J1.10 (GND), J1.11 (GND), J1.18 (GND), R1.2, R2.2
unnamed: R1.1, SW1.2
unnamed: R2.1, SW2.2

Notes on the sheet:
Through hole pin header for Nordic Dongle
The buttons are active low, meaning that the input will be connected to ground when the button is activated. The buttons have no external pull-up resistor, and therefore, to use the buttons, the pins must be configured as an input with an internal pull-up resistor.
Big buttons
Spring finger for battery sense
Clearance between batt holder and board is 1.5mm. Spring must be taller than this.
P1.15 is recommended for low frequency GPIO (<10kHz) due to proximity to the Antenna. Only used for pinging the RTC on startup.
GPIO not marked for any other function or low frequency include P0.13, 15, 17, 20, 22, 24, P1.00
~CS~ - P0.17 CLK - P0.19 SI - P0.20 SO - P0.21 ~WP~ - P0.22 ~RESET~ (SIO3 - pin7) - P0.23 Pinouts from development board schematic

Board: 2 copper layers, 45.3 x 27.5 mm, 6 parts (1 on the bottom side), 6 nets.

File BLEelectronics/ble_mvp_1A-rev2-ButtonDaughter/ble_mvp_1A-rev2-ButtonDaughter_06JUN20_JLCbom_clean.csv:

Comment,Designator,Footprint,LCSC Part #（optional）
0,R1 R2,R_0603_1608Metric,C21189
SW_Push,SW1 SW2,TS-1187A-SMD_button,C318886

## KiCad design BLEelectronics/uBit_carrier/uBit_carrier.kicad_pcb

Schematic: uBit_carrier.sch

Parts:
C1: 100nF; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSC C14663
C2, C3, C5: 1uF; C_0603_1608Metric; MPN C1608X5R1C105K080AA; LCSC C15849
C4, C6: 10uF; C_0805_2012Metric; MPN GCM21BR71A106KE22L; LCSCPN C15850
J1: microbit_edge_connector; 4UCON_10156_2x40_P1.27mm_Socket_Horizontal
J2: Conn_01x02_Male; JST_EH_S2B-EH_1x02_P2.50mm_Horizontal; MPN S2B-PH-SM4-TB(LF)(SN); LCSCPN C295747
J3: Micro_SD_Card_Det_Hirose_DM3AT; microSD_HC_Hirose_DM3AT-SF-PEJM5; MPN DM3AT-SF-PEJM5; LCSCPN C114218
R1: 17K4; R_0603_1608Metric; MPN AR03FTC1742; LCSCPN C22819
R2: 10K; R_0603_1608Metric; MPN RC0603JR-0710KL; LCSCPN C25804
R3: 100K; R_0603_1608Metric; MPN RMC0603100K5%N; LCSCPN C25803
U1: W25Q128JV; SOIC-8_5.23x5.23mm_P1.27mm; MPN W25Q128JVSIQ; LCSC C97521
U2: MCP1253-ADJI_MS; MPN MCP1253-ADJI/MS; LCSCPN C144295

Connections:
/3.3V: C1.2, C2.2, C4.2, J1.17 (P18_3v3), J1.19 (3v3), J1.21 (3v3), J1.23 (3v3), J1.25 (3v3), J1.27 (P17_3v3), J3.4 (VDD), R1.2, R3.2, U1.8 (VCC), U2.2
/CD: J1.49 (P10), J3.10 (DET_A)
/VIN: C3.2, C6.2, J2.1, U2.3, U2.7
/hold: J1.53 (P8), U1.7 (IO3)
/miso: J1.33 (P14_MISO), J3.7 (DAT0), U1.2 (DO(IO1))
/mosi: J1.31 (P15_MOSI), J3.3 (CMD), U1.5 (DI(IO0))
/sclk: J1.35 (P13_SCK), J3.5 (CLK), U1.6 (CLK)
/wp: J1.29 (P16), U1.3 (IO2)
/~CS0: J1.45 (P12), U1.1 (~CS)
/~CS1: J1.51 (P9), J3.2 (DAT3/CD)
GND: C1.1, C2.1, C3.1, C4.1, C6.1, J1.1 (P22_GND), J1.3 (GND), J1.5 (GND), J1.7 (GND), J1.9 (GND), J1.11 (P21_GND), J2.2, J3.6 (VSS), J3.11 (SHIELD), R2.2, U1.4 (GND), U2.4
unnamed: C5.1, U2.5
unnamed: C5.2, U2.6
unnamed: J1.37 (P2), J1.39 (P2), J1.41 (P2), J1.43 (P2)
unnamed: J1.55 (P1), J1.57 (P1), J1.59 (P1), J1.61 (P1)
unnamed: J1.71 (P0), J1.73 (P0), J1.75 (P0), J1.77 (P0)
unnamed: R1.1, R2.1, U2.8
unnamed: R3.1, U2.1

Notes on the sheet:
R1 = R2 * [(VOUT/VFB)-1] VOUT = VFB(1+R1/R2) VFB = 1.21V Let R2 = 10K and VOUT = 3.3V R1 = 10K*[(3.3/1.21) -1] = 17.3K check 1.21(1+17.3K/10K) = 3.303
CFLY
Driving ~SHDN~ low places the MCP1253 in a low-power shutdown mode. Pulling it high enables the chip.
Adj 3.3V Regulated DC/DC converter
JST Lipo battery input. SMD right angle 2-pin (Adafruit compatible).
~CSO~ to Pin16 Dedicated GPIO (Conventially used for SPI 'Chip Select') CD to Pin10 GPIO shared with LED Col 3 of the LED screen; can be used for ADC and digital I/O when the LED screen is turned off. WP to Pin9 GPIO shared with LED Col 7 of the LED screen; can be used for digital I/O when the LED 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

Board: 2 copper layers, 57.8 x 39.3 mm, 14 parts (0 on the bottom side), 18 nets.

File BLEelectronics/uBit_carrier/uBit_carrier_22MAY20_JLCformat_bom_ .csv:

100nF,C1,C_0603_1608Metric,C14663
10uF,C4 C6,C_0805_2012Metric,C15850
1uF,C2 C3 C5,C_0603_1608Metric,C29936
100K,R3,R_0603_1608Metric,C25803
10K,R2,R_0603_1608Metric,C25804
17K4,R1,R_0603_1608Metric,C22819
MCP1253,U2,MSOP-8_3.0X3.0X0.65P,C144295
W25Q128JV,U1,SOIC-8_5.23x5.23mm_P1.27mm,C113767

## KiCad design BLEelectronics/ble_mvp_1A-rev3/ble_mvp_1A-rev3.kicad_pcb

Parts:
C1, C4: 0.1uF; C_0603_1608Metric; MPN CC0603KRX7R9BB104; LCSCPN C14663
C2, C3: 1uF; C_0603_1608Metric; MPN C1608X5R1C105K080AA; LCSCPN C385893
D1: D_Schottky; D_SOD-123F; MPN SL14PL-TP; LCSCPN C417542
D2, D3: ESD401; ESD401DPYR; MPN ESD401DPYR; LCSCPN C316041
IC1: LTC4412xS6; TSOT-23-6; MPN LTC4412ES6#TRPBF; LCSCPN C107968
IC2: PCF8523T; SOIC-8_3.9x4.9mm_P1.27mm; MPN PCF8523T/1,118
IC3: MX25R6435FM2IL0; MPN MX25R6435FM2IL0
J1: Nordic_nRF52840_breakout; Nordic_nRF52840_FeatherHeader; MPN NRF52840-DONGLE
JP1: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
Q1: Si2307CDS; SOT-23; MPN SI2307CDS-T1-GE3; LCSCPN C141561
R1: 560K; R_0603_1608Metric; MPN RC0201FR-07560KL; LCSCPN C295807
R2, R3: 10K; R_0603_1608Metric; MPN RC0603JR-0710KL; LCSCPN C99198
U1: BAT-HLD-001; MPN BAT-HLD-001
U4: LP5907MFX-3.3; SOT-23-5; MPN LP5907MFX-3.3; LCSCPN C80670
X1: 32.768KHZ; Crystal_SMD_3215-2Pin_3.2x1.5mm; MPN CM7VT1A-LOWESR-32.768KHZ-12.5PF-20-TA-QC

Connections:
/3V: C1.1, D2.2, IC1.1 (VIN), JP1.1 (A), Q1.3 (D), U1.1, U1.3
/5Vusb: C2.2, D3.1, IC1.6 (SENSE), J1.20 (VBUS), U4.1 (IN), U4.3 (EN)
/CS: IC3.1 (CS#), J1.1 (P0.13)
/RESET: IC3.7 (RESET#/SIO3), J1.6 (P0.24)
/SCL: IC2.6 (SCL), J1.7 (P1.00), R3.2
/SCLK: IC3.6 (SCLK), J1.3 (P0.17)
/SDA: IC2.5 (SDA), J1.14 (P1.15), R2.2
/SI: IC3.5 (SI/SIO0), J1.5 (P0.22)
/SO: IC3.2 (SO/SIO1), J1.2 (P0.15)
/VDD_3V: C4.1, D1.1 (K), IC2.8 (VDD), IC3.8 (VCC), J1.19 (VDD_nRF), JP1.2 (B), Q1.2 (S), R1.1, R2.1, R3.1
/WP: IC3.3 (WP#/SIO2), J1.4 (P0.20)
GND: C1.2, C2.1, C3.1, C4.2, D2.1, D3.2, IC1.2 (GND), IC1.3 (CTL), IC2.4 (VSS), IC3.4 (GND), J1.10 (GND), J1.11 (GND), J1.18 (GND), U1.2, U4.2 (GND)
unnamed: C3.2, D1.2 (A), U4.5 (OUT)
unnamed: IC1.4 (STAT), R1.2
unnamed: IC1.5 (GATE), Q1.1 (G)
unnamed: IC2.1 (OSCI), X1.1
unnamed: IC2.2 (OSCO), X1.2

Notes on the sheet:
20mm diam. coin cell holder
Power source selection logic
CR2032/CR2025 Coin Cell holder and ESD/Surge protection
SPI interface flash memory with SPI
Real time clock module with i2c interface
GPIO not marked for any other function or low frequency include P0.13, 15, 17, 20, 22, 24, P1.00
P1.15 is recommended for low frequency GPIO (<10kHz) due to proximity to the Antenna. Only used for pinging the RTC on startup.
TVS diode for ESD
Need an external crystal
TVS diode for ESD protection
~CS~ - P0.17 CLK - P0.19 SI - P0.20 SO - P0.21 ~WP~ - P0.22 ~RESET~ (SIO3 - pin7) - P0.23 Pinouts from development board schematic
VDD powers chip. VBat is for time keeping backup with switching logic.
NON RECHARGEABLE VERSION
Through hole pin header for Nordic Dongle
NB: ~CS~ ~WP~ ~RESET~ use inverted logic

Board: 2 copper layers, 45.3 x 27.5 mm, 19 parts (0 on the bottom side), 17 nets.

## KiCad design BLEelectronics/ble_mvp_1B-rev0/ble_mvp_1b-rev0.kicad_pcb

Parts:
C1, C5: 0.1uF; C_0402_1005Metric; MPN GRM155R71H104ME14D
C2, C3, C4: 1uF; C_0402_1005Metric; MPN CL05A105KO5NNNC
C6: 0.01uF; C_0201_0603Metric; MPN C0603C103K4RECAUTO
C7: 4.7uF; C_0402_1005Metric; MPN CC0603KRX7R9BB104
C8, C9: 0.1uF; C_0201_0603Metric; MPN CC0603KPX7R9BB104
D1, D2: D_Schottky; D_SOD-123F; MPN SL14PL-TP
D3: PRTR5V0U2X; SOT-143; MPN PRTR5V0U2X,215
FB1, FB2: Ferrite_Bead; L_0402_1005Metric; MPN BKP1005EM331-T
IC1: LTC4412xS6; TSOT-23-6; MPN LTC4412ES6#TRPBF
IC2: LTC4054LES5-4.2#TRPBF; LTC4054LES5-4.2_TRPBF; MPN LTC4054LES5-4.2#TRPBF
IC3: PCF8523T; SOIC-8_3.9x4.9mm_P1.27mm; MPN PCF8523T/1,118
IC4: MX25R6435FM2IL0; MPN MX25R6435FM2IL0
J1: USB_B_Micro; USB_Micro-B_Molex-105017-0001; MPN 1050170001
JP1: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP2, JP3: Jumper_NO_Small; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
Q1: Si2307CDS; SOT-23; MPN SI2307CDS-T1-GE3
R2: 560K; R_0603_1608Metric; MPN RC0603JR-07560KL
R3: 1.69K; R_0402_1005Metric; MPN RC0402FR-071K69L
R5, R6: 10K; R_0402_1005Metric; MPN RC0402JR-0710KL
U1: BAT-HLD-001; BAT-HLD-001_smallerGND; MPN BAT-HLD-001
U2, U3: ESD401; ESD401DPYR; MPN ESD401DPYR
U4: LP5907MFX-3.3; SOT-23-5; MPN LP5907MFX-3.3
X3: 32.768KHZ; Crystal_SMD_3215-2Pin_3.2x1.5mm; MPN CM7VT1A-LOWESR-32.768KHZ-12.5PF-20-TA-QC

Connections:
/3V: C1.2, IC1.1 (VIN), JP1.1 (A), JP3.2, Q1.3 (D), U1.1, U1.3, U2.2
/5Vusb: C2.2, C8.2, FB2.1, IC1.6 (SENSE), JP2.1, U4.1 (IN), U4.3 (EN)
/D+: D3.2 (I/O1), J1.3 (D+); also elsewhere on the board
/D-: D3.3 (I/O2), J1.2 (D-); also elsewhere on the board
/SCL: IC3.6 (SCL), R6.2; also elsewhere on the board
/SCLK: IC4.6 (SCLK); also elsewhere on the board
/SDA: IC3.5 (SDA), R5.2; also elsewhere on the board
/SI: IC4.5 (SI/SIO0); also elsewhere on the board
/SO: IC4.2 (SO/SIO1); also elsewhere on the board
/VDD_3V: C5.2, D1.1 (K), IC3.8 (VDD), IC4.8 (VCC), JP1.2 (B), Q1.2 (S), R2.1, R5.1, R6.1; also elsewhere on the board
/flash~RESET~: IC4.7 (RESET#/SIO3); also elsewhere on the board
/~CS~: IC4.1 (CS#); also elsewhere on the board
/~INT1~: IC3.7 (~INT1~/CLKOUT); also elsewhere on the board
/~WP~: IC4.3 (WP#/SIO2)
GND: C1.1, C2.1, C3.2, C4.1, C5.1, C6.1, C7.2, C8.1, C9.1, D3.1 (GND), FB1.1, IC1.2 (GND), IC1.3 (CTL), IC2.2 (GND), IC3.4 (VSS), IC4.4 (GND), J1.6 (Shield), R3.2, U1.2, U2.1, U3.2, U4.2 (GND); also elsewhere on the board
unnamed: C3.1, IC2.4 (VCC), JP2.2
unnamed: C4.2, D1.2 (A), U4.5 (OUT)
unnamed: C6.2, C7.1, C9.2, D3.4 (VCC), FB2.2, J1.1 (VBUS), U3.1
unnamed: D2.1 (K), JP3.1
unnamed: D2.2 (A), IC2.3 (BAT)
unnamed: FB1.2, J1.5 (GND)
unnamed: IC1.4 (STAT), R2.2
unnamed: IC1.5 (GATE), Q1.1 (G)
unnamed: IC2.5 (PROG), R3.1
unnamed: IC3.1 (OSCI), X3.1
unnamed: IC3.2 (OSCO), X3.2

Notes on the sheet:
20mm diam. coin cell holder
Coin cell charger circuit
CR2032/CR2025 Coin Cell holder and ESD/Surge protection
SPI interface flash memory with SPI
Real time clock module with i2c interface
TVS diode for ESD
Need an external crystal
Added a Schottkey Diode
Power source selection logic
TVS diode for ESD protection
ESD protection on USB data
CONFIRM: Ferrite Bead selection
Switched to TVS diode PRTR5V0U2X,215
The schematics include an optional series resistor on the USB supply for improved immunity to transient overvoltage during VBUS connection. Using the series resistor is recommended for new designs. Value 4R7 (4.5ohms?) from pae 585
Note: There is no reverse voltage protection on the power connections. (pg 14 Dongle guide)
Q: Do we change the ESD to be the same as the dongle? PRTR5V0U2X
VDD powers chip. VBat is for time keeping backup with switching logic.
NB: CS# uses inverted logic

Parts:
C10, C14: 1pF; C_0201_0603Metric
C11, C17: N.C.; C_0201_0603Metric
C12, C13, C25, C26: 12pF; C_0201_0603Metric
C15: 1.5pF; C_0201_0603Metric
C16: 0.01uF; C_0402_1005Metric
C18: 100pF; C_0201_0603Metric
C20, C22: 4.7uF; C_0603_1608Metric
C21: 820pF; C_0201_0603Metric
C23, C24: 1uF; C_0603_1608Metric
C27, C28: 100nF; C_0201_0603Metric
C29: 47nF; C_0201_0603Metric
C30: 0.1uF; C_0201_0603Metric
C31: 0.01uF; C_0201_0603Metric
D4: LED_ABRG; LED_APHF1608SEEQBDZGKC; MPN APHF1608SEEQBDZGKC
D5: LED; LED_0603_1608Metric
J3: Conn_02x05_Odd_Even; TC2050-IDC-NLFP
L1: 3.9nH; L_0201_0603Metric
L2, L3: 10uH; L_0603_1608Metric
L4: 15nH; L_0402_1005Metric
R7: 220; R_0201_0603Metric; MPN ERJ-1GNJ221C
R8: 1K2; R_0201_0603Metric; MPN AC0201FR-071K2L
R9: 2K2; R_0201_0603Metric; MPN RC0201FR-072K2L
R10: 390; R_0201_0603Metric; MPN RC0201FR-07390RL
R11: 0; R_0201_0603Metric; MPN RC0201JR-070RL
R12: 10K; R_0201_0603Metric; MPN AC0201FR-0710KL
SW1: NO; EVQP7A_J_B_K; MPN PTS840 GK SMTR LFS
SW2: SW_MEC_5G; C&K_PTS810; MPN PTS810 SJK 250 SMTR LFS
U5: nRF52840; Nordic_AQFN-73-1EP_7x7mm_P0.5mm
X1: 32MHz; Crystal_SMD_2016-4Pin_2.0x1.6mm; MPN NX2016AB-32MHZ ST2
X2: 32.768KHZ; Crystal_SMD_3215-2Pin_3.2x1.5mm; MPN RT3215-32.768-9-TR

Connections:
/D+: U5.AD6 (D+); also elsewhere on the board
/D-: U5.AD4 (D-); also elsewhere on the board
/SCL: U5.AD22 (TRACEDATA0/P1.00); also elsewhere on the board
/SCLK: U5.AD16 (P0.20); also elsewhere on the board
/SDA: U5.A14 (P1.15); also elsewhere on the board
/SI: U5.AD20 (P0.24); also elsewhere on the board
/SO: U5.AD12 (P0.17); also elsewhere on the board
/VDD_3V: C20.1, C23.2, C28.2, C31.2, D4.1, D5.2 (A), J3.1, L2.1, R12.1, U5.A22 (VDD), U5.AD14 (VDD), U5.B1 (VDD), U5.W1 (VDD), U5.Y2 (VDDH); also elsewhere on the board
/flash~RESET~: U5.AD8 (P0.13); also elsewhere on the board
/nRF52840_QIAA_R/ANTENNA: C10.1, R11.2
/nRF52840_QIAA_R/LED1: R7.2, U5.L1 (P0.06)
/nRF52840_QIAA_R/LED2_B: R9.2, U5.U1 (TRACEDATA1/P0.12)
/nRF52840_QIAA_R/LED2_G: R10.2, U5.R1 (TRACEDATA3/P1.09)
/nRF52840_QIAA_R/LED2_R: R8.2, U5.N1 (P0.08)
/nRF52840_QIAA_R/RESET: C27.1, J3.10, R12.2, SW1.1, U5.AC13 (P0.18/~RESET), U5.AC15 (P0.19), U5.AC17 (P0.21), U5.AC19 (P0.23), U5.AC21 (P0.25)
/nRF52840_QIAA_R/SW1: SW2.1, U5.R24 (P1.06)
/nRF52840_QIAA_R/SWDCLK: J3.4, U5.AA24 (SWDCLK)
/nRF52840_QIAA_R/SWDIO: J3.2, U5.AC24 (SWDIO)
/~CS~: U5.AD10 (P0.15); also elsewhere on the board
/~INT1~: U5.A16 (P1.13); also elsewhere on the board
/~WP: U5.AD18 (P0.22)
GND: C10.2, C11.2, C12.1, C13.1, C14.2, C15.2, C16.2, C17.2, C18.1, C20.2, C21.2, C22.2, C23.1, C24.2, C25.1, C26.1, C27.2, C28.1, C29.1, C30.2, C31.1, J3.3, J3.5, J3.9, SW1.2, SW2.2, U5.B7 (VSS), U5.F23 (VSS_PA), X1.2, X1.4; also elsewhere on the board
unnamed: C11.1, C14.1, L1.1, R11.1
unnamed: C12.2, U5.B24 (XC1), X1.3
unnamed: C13.2, U5.A23 (XC2), X1.1
unnamed: C15.1, L1.2, U5.H23 (ANT)
unnamed: C16.1, U5.C1 (DEC1)
unnamed: C17.1, U5.A18 (DEC2)
unnamed: C18.2, U5.D23 (DEC3)
unnamed: C21.1, U5.N24 (DEC5)
unnamed: C22.1, U5.AC5 (DECUSB)
unnamed: C24.1, C29.2, L4.1, U5.B5 (DEC4), U5.E24 (DEC6)
unnamed: C25.2, U5.D2 (XL1/P0.00), X2.1
unnamed: C26.2, U5.F2 (XL2/P0.01), X2.2
unnamed: C30.1, U5.AD23 (VDD)
unnamed: D4.2, R8.1
unnamed: D4.3, R9.1
unnamed: D4.4, R10.1
unnamed: D5.1 (K), R7.1
unnamed: L2.2, U5.AB2 (DCCH)
unnamed: L3.1, L4.2
unnamed: L3.2, U5.B3 (DCC)

Notes on the sheet:
Confirm no pull-up/down resistors for SPI protocol
P1.15 is a low frequency GPIO (<10kHz)
GPIO not marked for any other function or low frequency include P0.13, 15, 17, 20, 22, 24, P1.00
GPIO not marked for any other function or low frequency include P0.13, 15, 17, 20, 22, 24, P1.00
~CS~ - P0.17 CLK - P0.19 SI - P0.20 SO - P0.21 ~WP~ - P0.22 SIO3/HOLD/~RESET~ (pin7) - P0.23 Pinouts from development board schematic
Details from Dongle User Guide pg 13 The buttons are active low, which means that the input will be connected to ground when the button is activated. The SW1 button has no external pull-up resistor, but the reset button (SW2) has a 10 k pull-up resistor. To use SW1, P1.06 must be configured as an i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
Low Freq XTAL
VDD shorted to VDDH Same as cut SB2, jump SB1 on Nordic dongle
POGO header 2x5, 1.27mm J2 in dongle schematic
LEDs are active low, which means that writing a logical zero '0' to the output pin will illuminate the LED. LED footprint and component
Prod spec v1.1 pg 583 for reference circuit for RF Antenna
The reference schematics use v1.1 component values, which are recommended for new designs to improve the margin for spurious emissions during regulatory approval tests.
Circuits taken from the Nordic Dongle layout and configuration 5, ref in table 146 on pg 586 of Prod Spec v1.1 Battery/Ext. regulator to VDD, USB enabled. This is for chip QIAA aQFN 73, the non BGA version
Do we connect VDD to DCCH? Dongle does, reference config 5 in prod spec has it NC.
DEC4 (A8) must short to DEC6 (C2) Ref pg579 of prod spec v1.1
Check R for LEDs
The 32.768 kHz crystal (X2) is required for correct operation when using ANT/ANT+.
Note: There is no reverse voltage protection on the power connections. (pg 14 Dongle guide)
Removed NC cap E24-D23

Board: 2 copper layers, 36.0 x 29.3 mm, 71 parts (1 on the bottom side), 54 nets.

## KiCad design BLEelectronics/NonRecharge_CR2025_Nordic_adapt/CR2025_Nordic/CR2025_Nordic.kicad_pcb

Board: 2 copper layers, 24 parts (1 on the bottom side), 13 nets, no tracks yet.

Parts:
A1: Nordic_nRF52840_breakout; Adafruit_HUZZAH_ESP8266_breakout
C1, C2: 0.1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
C3, C4, C5: 1uF; C_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D1, D2: TPD1E10B06DPYR; DIODFN100X60X45-2N
D3: D_Schottky; D_SOD-123F
FID1, FID2: Fiducial; Fiducial_0.5mm_Mask1mm
Q1: Si2307CDS; SOT-23
R1, R2, R3, R5, R7: 0; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R4: 560K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R6: 1.69K; R_0603_1608Metric_Pad1.05x0.95mm_HandSolder
U1: LP5907MFX-3.3; SOT-23-5
U2: BAT-HLD-001
U3: LTC4412xS6; TSOT-23-6
U4: LTC4054LES5-4.2#TRPBF; LTC4054LES5-4.2_TRPBF
U5: MX25R6435FM2IL0; TSSOP-8_4.4x3mm_P0.65mm

Connections:
/3V: C1.1, D2.2, Q1.3, R7.1, U2.1, U2.3, U3.1
/5Vusb: A1.20, D1.1, D3.2, R5.1, U3.6
/VDD_3V: A1.19, C2.1, R2.1, R3.1, R4.1, U5.8
GND: A1.10, A1.11, A1.18, C1.2, C2.2, C3.2, C4.1, C5.1, D1.2, D2.1, R1.2, R6.2, U2.2, U4.2, U5.4
unnamed: C3.1, R5.2, U4.4
unnamed: C4.2, D3.1, U1.1, U1.3
unnamed: C5.2, R2.2, U1.5
unnamed: Q1.1, U3.5
unnamed: Q1.2, R3.2
unnamed: R1.1, U3.2, U3.3
unnamed: R4.2, U3.4
unnamed: R6.1, U4.5
unnamed: R7.2, U4.3

File BLEelectronics/ble_mvp_1A-rev1/CR2025_Nordic_bom_lcsc.csv:

Comment,Designator,Footprint,LCSC Part #?optional?
0.1uF,C1 C2,0603_C,C14663
1uF,C3 C4 C5,0603_C,C385893
D_Schottky,D3 D4,D_SOD-123F,C417542
LTC4054LES5-4.2#TRPBF,IC4,TSOT-23-5,C462691
LTC4412xS6,IC1,TSOT-23-6,C107968
Si2307CDS,Q1,SOT-23,C141561
1.69K,R6,0603_R,C227658
10K,R8 R9,0603_R,C99198
560K,R4,0603_R,C295807
ESD401,U3 U4,402,C316041
LP5907MFX-3.3,U1,SOT-23-5,C80670

Notices in the files:
parts and their libraries:
Copyright 2016 Accelerated Designs. All rights reserved.
